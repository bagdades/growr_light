# Repository bagdades/growr_light

## KiCad design kicad/grower_light/grower_light.kicad_pcb

Parts:
C1, C2, C5: 100n; C_0805_2012Metric
C3: 10u; CP_Radial_D5.0mm_P2.50mm
C4: 100n; C_Axial_L3.8mm_D2.6mm_P7.50mm_Horizontal
C6: 2u2; C_1206_3216Metric
D1: LED; LED_D3.0mm
F1: Fuse; Fuseholder_TR5_Littlefuse_No560_No460
J1: AC; PinHeader_1x02_P2.54mm_Vertical
J2: AC_IN; RF-190F
J3: PWR_+5V; PinHeader_1x02_P2.54mm_Vertical
J4: OUTPUT; mors_2p
J6: ESP_UART; PinHeader_1x03_P2.54mm_Vertical
J7: Sensors; mors_3p
Q1: BT139-600; TO-220-3_Vertical
Q2, Q3: BSS138; SOT-23
R1: 240; R_0805_2012Metric
R2: 51; R_Axial_DIN0207_L6.3mm_D2.5mm_P15.24mm_Horizontal
R3: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P15.24mm_Horizontal
R4: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P15.24mm_Horizontal
R5: 27k; R_0805_2012Metric
R6: 1k; R_0805_2012Metric
R7: 100; R_0805_2012Metric
R8: 12k; R_0805_2012Metric
R9: 220; R_0805_2012Metric
R10, R12: 10k; R_0805_2012Metric
R11: 470k; R_0805_2012Metric
R13: 100k; R_0805_2012Metric
SW1: RESET; SW_Tactile_SPST_Angled_PTS645Vx39-2LFS
U1: MOC3023M; DIP-6_W7.62mm
U2: LD1117S33TR_SOT223; SOT-223-3_TabPin2
U3: ESP-12_07v2; ESP-07v2

Connections:
+3V3: C2.2, C3.1, R7.2, R11.1, R12.1, U2.2 (VO), U3.8
+5V: C1.2, J3.2, U2.3 (VI)
/ADC: J7.2, R5.1, R6.1, R8.2, U3.2
/LED: R9.2, U3.11
/ML: J7.3, R8.1, U3.6
/MLP: R5.2, U3.7
/MT: J7.1, U3.5
/MTP: R6.2, U3.13
/OUT: R1.2, U3.14
/RESET: C5.1, Q2.1 (G), SW1.1, U3.1
/RX: J6.2, U3.15
/TX: J6.1, U3.16
GND: C1.1, C2.1, C3.2, C5.2, C6.2, D1.1 (K), J3.1, J6.3, Q2.2 (S), Q3.2 (S), R10.1, SW1.2, U1.2, U2.1 (GND), U3.9
unnamed: C4.1, R2.2
unnamed: C4.2, J1.1, J2.1, Q1.1 (A1), R4.2
unnamed: C6.1, Q3.1 (G), R13.1
unnamed: D1.2 (A), R9.1
unnamed: F1.1, J1.2, J4.1
unnamed: F1.2, J2.2
unnamed: J4.2, Q1.2 (A2), R2.1, U1.6
unnamed: Q1.3 (G), R3.2, R4.1
unnamed: Q2.3 (D), R11.2, R13.2
unnamed: Q3.3 (D), R12.2, U3.12
unnamed: R1.1, U1.1
unnamed: R3.1, U1.4
unnamed: R7.1, U3.3
unnamed: R10.2, U3.10

Notes on the sheet:
GPIO14(5)
GPIO12(6)
GPIO13(7)
GPIO4(2)

Board: 2 copper layers, 98.0 x 41.0 mm, 34 parts (18 on the bottom side), 27 nets.

## Commit log

2018-01-23 Add source and update schematic
2018-01-24 Add ds1307 clock
2018-01-27 Add i2c protocol and ds1307 functions
2018-01-27 Add eeprom save setting
2018-01-28 Prefinish work
2018-01-28 Correct time cuts
2018-01-30 Start work with pcb
2018-02-11 Work with esp, greate server and html
2018-02-18 Create server witch cfg
2018-02-18 Add function save config index.html & time show
2018-02-21 End of work with web page
2018-02-24 Set function light on off
2018-02-26 Work with interface
2018-02-27 Set controll with light
2018-03-02 Test version
2018-03-02 Test build
2018-03-03 Change schematic for only esp8266
2018-03-03 Drawing schematic new
2018-03-04 Final pcb
2019-02-23 Transfer
